# Keil uVision project gpio_output.uvprojx, settings and files
target gpio_output_Release (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32L126KATB HDSC
  pack: HDSC.HC32L12x.1.1.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(48000000) ELITTLE
  output: gpio_output +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\driver\inc;..\source;..\mcu\common;..\my_driver;..\cjson;..\FreeRtos\include;..\app
  library: MicroLIB
  memory RVCT4: ROM 0x3000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32l12x.s
    ../mcu/common/: interrupts_hc32l12x.c system_hc32l12x.c
  group App
    ../app/: main.c app_work_1.c app_work_2.c app_work_3.c app_work_4.c
  group source
    ../source/: bsp_log.c bsp_gas.c bsp_key.c bsp_part.c bsp_valve.c bsp_factory.c bsp_eeprom.c bsp_module.c bsp_protocol_fct.c bsp_sound_led.c bsp_queue.c bsp_string.c bsp_xmodem.c
  group my_driver
    ../my_driver/: driver_rtc.c driver_adc.c driver_uart.c driver_timer.c driver_flash.c driver_gpio.c driver_iwdt.c driver_lpuart.c driver_lptim.c driver_pwm.c
  group rtos/prots
    ../FreeRtos/portable/RVDS/ARM_CM0/: port.c
  group rtos/source
    ../FreeRtos/: list.c task.c
  group driver
    ../driver/src/: adc.c aes.c bt.c crc.c ctrim.c ddl.c debug.c dmac.c flash.c gpio.c hsi2c.c i2c.c iwdt.c lcd.c lpm.c lptim.c lpuart.c lvd.c ram.c reset.c rtc.c spi.c sysctrl.c timer3.c trng.c usart.c vc.c wwdt.c
  group README
    ../: readme.txt
software components: CMSIS:CORE 5.4.0
